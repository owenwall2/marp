options:
  parameters:
    generate_options: qt_gui
    id: adsb_app
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: adsb_decoder_0
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"Extended Squitter Only"'
    print_level: '"Brief"'
  states: {}
- name: adsb_demod_0
  id: adsb_demod
  parameters:
    fs: 2e6
  states: {}
- name: adsb_framer_0
  id: adsb_framer
  parameters:
    fs: 2e6
    threshold: '0.01'
  states: {}
- name: adsb_map_plotter_0
  id: adsb_map_plotter
  parameters:
    home_lat: '34.676'
    home_lon: '-82.837'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: iio_fmcomms2_source_1
  id: iio_fmcomms2_source
  parameters:
    auto_filter: 'True'
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: 1090*10**6
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: '2000000'
    uri: ip:192.168.65.254
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '900000'
    decim: '1'
    gain: '1'
    samp_rate: '2000000'
    type: fir_filter_ccf
    width: '200000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '300'
    srate: '2000'
    type: float
  states: {}

connections:
- [adsb_decoder_0, decoded, adsb_map_plotter_0, in]
- [adsb_demod_0, '0', qtgui_time_sink_x_0, '0']
- [adsb_demod_0, demodulated, adsb_decoder_0, demodulated]
- [adsb_framer_0, '0', adsb_demod_0, '0']
- [blocks_complex_to_float_0, '0', adsb_framer_0, '0']
- [blocks_complex_to_float_0, '1', blocks_null_sink_0, '0']
- [iio_fmcomms2_source_1, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
